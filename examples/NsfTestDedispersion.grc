<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>NsfIntegrate30rtlsdr</value></param>
<param><key>author</key><value>Glen Langston</value></param>
<param><key>description</key><value>RTL SDR Dongle</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>NsfIntegrate: Average+Record Astronomical Obs.</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>Azimuth</value></param>
<param><key>value</key><value>Azimuth_save</value></param>
<param><key>gui_hint</key><value>0,5,1,1</value></param>
<param><key>label</key><value>Azimuth</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>Azimuth_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>90.</value></param>
<param><key>option</key><value>azimuth</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>Azimuth</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>Bandwidth</value></param>
<param><key>value</key><value>Bandwidths</value></param>
<param><key>gui_hint</key><value>1,6,1,1</value></param>
<param><key>label</key><value>Bandwidth</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>Bandwidths</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>3.e6</value></param>
<param><key>option</key><value>Bandwidth</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>Bandwidth</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ConfigFile</value></param>
<param><key>value</key><value>"Watch30rtlsdr.conf"</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>Device</value></param>
<param><key>value</key><value>device_save</value></param>
<param><key>gui_hint</key><value>2,0,1,2</value></param>
<param><key>label</key><value>Dev</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>Elevation</value></param>
<param><key>value</key><value>Elevation_save</value></param>
<param><key>gui_hint</key><value>0,6,1,1</value></param>
<param><key>label</key><value>Elevation</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>Elevation_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>90.</value></param>
<param><key>option</key><value>elevation</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>Elevation</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>Frequency</value></param>
<param><key>value</key><value>Frequencys</value></param>
<param><key>gui_hint</key><value>1,5,1,1</value></param>
<param><key>label</key><value>Freq. Hz</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>Frequencys</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>1420.4e6</value></param>
<param><key>option</key><value>Frequency</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>Frequency</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>Gain1</value></param>
<param><key>value</key><value>Gain1s</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>label</key><value>Gain1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>Gain1s</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>49.</value></param>
<param><key>option</key><value>gain1</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>Gain1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>H1</value></param>
<param><key>value</key><value>1420.406E6</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>Record</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>7,0,1,1</value></param>
<param><key>label0</key><value>! ! Wait ! !</value></param>
<param><key>label1</key><value>AVERAGE</value></param>
<param><key>label2</key><value>Save</value></param>
<param><key>label</key><value>Rec</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>Telescope</value></param>
<param><key>value</key><value>telescope_save</value></param>
<param><key>gui_hint</key><value>1,0,1,2</value></param>
<param><key>label</key><value>Tel</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>VelFrame</value></param>
<param><key>value</key><value>frame_save</value></param>
<param><key>gui_hint</key><value>11,0,1,1</value></param>
<param><key>label0</key><value>Topocentric</value></param>
<param><key>label1</key><value>LSRK</value></param>
<param><key>label2</key><value>Barycentric</value></param>
<param><key>label</key><value>Frame</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>Xaxis</value></param>
<param><key>value</key><value>xaxis_save</value></param>
<param><key>gui_hint</key><value>11,4,1,2</value></param>
<param><key>label0</key><value>Frequency (MHz)</value></param>
<param><key>label1</key><value>Velocity (km/sec)</value></param>
<param><key>label2</key><value>Channels</value></param>
<param><key>label</key><value>Xaxis</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>device_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>rtl=0,bias=1</value></param>
<param><key>option</key><value>device</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>Device</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>fftsize</value></param>
<param><key>value</key><value>fftsize_save</value></param>
<param><key>gui_hint</key><value>1,3,1,1</value></param>
<param><key>label</key><value>FFT_size</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>fftsize_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>128</value></param>
<param><key>option</key><value>fftsize</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>fftsize</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>frame_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>Frame</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>VelFrame</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>nAve</value></param>
<param><key>value</key><value>nAves</value></param>
<param><key>gui_hint</key><value>0,3,1,1</value></param>
<param><key>label</key><value>N_Ave.</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>nAves</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>20</value></param>
<param><key>option</key><value>nave</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>nAve</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>numin</value></param>
<param><key>value</key><value>(Frequency - (Bandwidth/2.))</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>observer</value></param>
<param><key>value</key><value>observers_save</value></param>
<param><key>gui_hint</key><value>0,0,1,2</value></param>
<param><key>label</key><value>Who</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>observers_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>Katherine, Nathaniel, Glen</value></param>
<param><key>option</key><value>observers</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>observer</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>obstype</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>8,0,1,1</value></param>
<param><key>label0</key><value>Survey</value></param>
<param><key>label1</key><value>Hot</value></param>
<param><key>label2</key><value>Cold</value></param>
<param><key>label3</key><value>Ref</value></param>
<param><key>label</key><value>Obs</value></param>
<param><key>num_opts</key><value>4</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>option3</key><value>3</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>telescope_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>Bubble Wrap Horn</value></param>
<param><key>option</key><value>telescope</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>Telescope</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>units</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>9,0,1,1</value></param>
<param><key>label0</key><value>Counts</value></param>
<param><key>label1</key><value>dB</value></param>
<param><key>label2</key><value>Kelvins</value></param>
<param><key>label</key><value>Units</value></param>
<param><key>num_opts</key><value>3</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>xaxis_save</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>Xaxis</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>Xaxis</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>xaxis_save_0</value></param>
<param><key>config_file</key><value>ConfigFile</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>Xaxis</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>Xaxis</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xmins</value></param>
<param><key>value</key><value>[numin*1E-6, (H1 - numin)*(3E5/H1), 0 ]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xsteps</value></param>
<param><key>value</key><value>[Bandwidth*1.E-6/fftsize, -Bandwidth*3.E5/(H1*fftsize), 1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ymaxs</value></param>
<param><key>value</key><value>[1., 10., 180.]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ymins</value></param>
<param><key>value</key><value>[ 0.01,  -20,  90.] </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>yunits</value></param>
<param><key>value</key><value>["Counts", "Power (dB)", "Intensity (Kelvins)"]</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>Count_note</value></param>
<param><key>note</key><value>Ascii_sink nMedian must match the number of Medians to the 4th power</value></param>
</block>
<block>
<key>Ra_Ascii_Sink</key>
<param><key>id</key><value>Ra_Ascii_Sink_0</value></param>
<param><key>azimuth</key><value>Azimuth</value></param>
<param><key>bandwidth</key><value>Bandwidth</value></param>
<param><key>device</key><value>Device</value></param>
<param><key>elevation</key><value>Elevation</value></param>
<param><key>frequency</key><value>Frequency</value></param>
<param><key>gain1</key><value>Gain1</value></param>
<param><key>gain2</key><value>12</value></param>
<param><key>gain3</key><value>12</value></param>
<param><key>observers</key><value>observer</value></param>
<param><key>obstype</key><value>obstype</value></param>
<param><key>record</key><value>Record</value></param>
<param><key>setup</key><value>Watch.not</value></param>
<param><key>site</key><value>Telescope</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>nave</key><value>nAve</value></param>
<param><key>nmedian</key><value>4**5</value></param>
</block>
<block>
<key>Ra_Integrate</key>
<param><key>id</key><value>Ra_Integrate_1</value></param>
<param><key>azimuth</key><value>Azimuth</value></param>
<param><key>bandwidth</key><value>Bandwidth</value></param>
<param><key>count</key><value>(4**5)</value></param>
<param><key>elevation</key><value>Elevation</value></param>
<param><key>frequency</key><value>Frequency</value></param>
<param><key>inttype</key><value>Record</value></param>
<param><key>observers</key><value>observer</value></param>
<param><key>obstype</key><value>obstype</value></param>
<param><key>setup</key><value>str(ConfigFile)</value></param>
<param><key>tcold</key><value>10.</value></param>
<param><key>thot</key><value>295.</value></param>
<param><key>units</key><value>units</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fftsize*8</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fftsize</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fftsize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.hamming(fftsize)</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>The sequence of vector medians removes temporary RFI</value></param>
</block>
<block>
<key>qtgui_histogram_sink_x</key>
<param><key>id</key><value>qtgui_histogram_sink_x_0</value></param>
<param><key>gui_hint</key><value>4,0,3,1</value></param>
<param><key>label1</key><value>I</value></param>
<param><key>label2</key><value>Q</value></param>
<param><key>xmax</key><value>.5</value></param>
<param><key>xmin</key><value>-.5</value></param>
<param><key>bins</key><value>100</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>1</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>gui_hint</key><value>11,6,1,2</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label1</key><value>T Remains:</value></param>
<param><key>unit1</key><value>(s)</value></param>
<param><key>max</key><value>nAve * fftsize * 1024. / Bandwidth</value></param>
<param><key>min</key><value>0</value></param>
<param><key>update_time</key><value>1</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>gui_hint</key><value>2,1,8,6</value></param>
<param><key>alpha1</key><value>2.</value></param>
<param><key>color1</key><value>"black"</value></param>
<param><key>label1</key><value>Latest</value></param>
<param><key>color2</key><value>"dark green"</value></param>
<param><key>label2</key><value>Median</value></param>
<param><key>width2</key><value>2</value></param>
<param><key>color3</key><value>"red"</value></param>
<param><key>label3</key><value>Hot</value></param>
<param><key>color4</key><value>"blue"</value></param>
<param><key>label4</key><value>Cold</value></param>
<param><key>label5</key><value>Ref</value></param>
<param><key>width5</key><value>2</value></param>
<param><key>nconnections</key><value>5</value></param>
<param><key>ref_level</key><value>0.25*(ymins[units] + (3.*ymaxs[units]))</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>update_time</key><value>1</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>x_axis_label</key><value>""</value></param>
<param><key>x_start</key><value>xmins[Xaxis]</value></param>
<param><key>x_step</key><value>xsteps[Xaxis]</value></param>
<param><key>ymax</key><value>ymaxs[units]</value></param>
<param><key>ymin</key><value>ymins[units]</value></param>
<param><key>y_axis_label</key><value>"Power"</value></param>
</block>
<block>
<key>ra_vmedian</key>
<param><key>id</key><value>ra_vmedian_1</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>ra_vmedian</key>
<param><key>id</key><value>ra_vmedian_2</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>ra_vmedian</key>
<param><key>id</key><value>ra_vmedian_3</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>ra_vmedian</key>
<param><key>id</key><value>ra_vmedian_4</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>ra_vmedian</key>
<param><key>id</key><value>ra_vmedian_5</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>radio_astro_dedispersion</key>
<param><key>id</key><value>radio_astro_dedispersion_0</value></param>
<param><key>bw</key><value>Bandwidth</value></param>
<param><key>dms</key><value>56.1</value></param>
<param><key>f_obs</key><value>Frequency</value></param>
<param><key>nt</key><value>fftsize</value></param>
<param><key>t_int</key><value>fftsize/Bandwidth</value></param>
<param><key>vec_length</key><value>fftsize*8</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>12</value></param>
<param><key>bw0</key><value>Bandwidth</value></param>
<param><key>freq0</key><value>Frequency</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>12</value></param>
<param><key>gain0</key><value>Gain1</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>args</key><value>Device</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>Bandwidth</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>Ra_Ascii_Sink_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Ra_Integrate_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>Ra_Integrate_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>Ra_Integrate_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>Ra_Integrate_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Ra_Integrate_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>qtgui_histogram_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>qtgui_histogram_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>radio_astro_dedispersion_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ra_vmedian_1</source_block_id><sink_block_id>ra_vmedian_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ra_vmedian_2</source_block_id><sink_block_id>ra_vmedian_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ra_vmedian_3</source_block_id><sink_block_id>ra_vmedian_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ra_vmedian_4</source_block_id><sink_block_id>ra_vmedian_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ra_vmedian_5</source_block_id><sink_block_id>Ra_Ascii_Sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ra_vmedian_5</source_block_id><sink_block_id>Ra_Integrate_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radio_astro_dedispersion_0</source_block_id><sink_block_id>ra_vmedian_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

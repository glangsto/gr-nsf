<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>vectordemo</value></param>
<param><key>author</key><value>Glen Langston</value></param>
<param><key>description</key><value>This GRC demo compares the outputs of average and median with straght vector plotting</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Vector averaging and median comparison</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftsize</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>.1</value></param>
<param><key>freq</key><value>3e5</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>.05</value></param>
<param><key>freq</key><value>2e5</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>[50.]*fftsize</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0_0</value></param>
<param><key>const</key><value>[0.]*fftsize</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0_1</value></param>
<param><key>const</key><value>[100.]*fftsize</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>3</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>4</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0_0</value></param>
<param><key>n</key><value>4</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fftsize</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>False</value></param>
<param><key>window</key><value>window.blackmanharris(fftsize)</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>alpha1</key><value>1</value></param>
<param><key>color1</key><value>"black"</value></param>
<param><key>label1</key><value>One in 4</value></param>
<param><key>color2</key><value>"blue"</value></param>
<param><key>label2</key><value>Average</value></param>
<param><key>width2</key><value>2</value></param>
<param><key>label3</key><value>Median</value></param>
<param><key>width3</key><value>2</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0</value></param>
<param><key>ymax</key><value>150</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>alpha1</key><value>1</value></param>
<param><key>color1</key><value>"black"</value></param>
<param><key>label1</key><value>One in 4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>update_time</key><value>1</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0</value></param>
<param><key>ymax</key><value>150</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>ra_vave</key>
<param><key>id</key><value>ra_vave_0</value></param>
<param><key>vdecimate</key><value>4</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>ra_vave</key>
<param><key>id</key><value>ra_vave_0_0</value></param>
<param><key>vdecimate</key><value>4</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>ra_vmedian</key>
<param><key>id</key><value>ra_vmedian_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>ra_vmedian</key>
<param><key>id</key><value>ra_vmedian_0_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>ra_vmedian</key>
<param><key>id</key><value>ra_vmedian_0_0_0</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>ra_vmedian</key>
<param><key>id</key><value>ra_vmedian_0_0_1</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>ra_vmedian</key>
<param><key>id</key><value>ra_vmedian_0_1</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<block>
<key>ra_vmedian</key>
<param><key>id</key><value>ra_vmedian_0_2</value></param>
<param><key>vlen</key><value>fftsize</value></param>
<param><key>vdecimate</key><value>4</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>ra_vave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>ra_vmedian_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ra_vave_0</source_block_id><sink_block_id>ra_vave_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ra_vave_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ra_vmedian_0</source_block_id><sink_block_id>ra_vmedian_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ra_vmedian_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ra_vmedian_0_0</source_block_id><sink_block_id>ra_vmedian_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ra_vmedian_0_0_0</source_block_id><sink_block_id>ra_vmedian_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ra_vmedian_0_0_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ra_vmedian_0_1</source_block_id><sink_block_id>ra_vmedian_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ra_vmedian_0_2</source_block_id><sink_block_id>ra_vmedian_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
